# Keil uVision project uCOS-III-F103.uvprojx, settings and files
target uCOS-III-F103 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uCOS-III-F103 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\APP;..\User\BSP;..\User\uC-CPU;..\User\uC-CPU\ARM-Cortex-M3\RealView;..\User\uC-LIB;..\User\uCOS-III\Source;..\User\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\User\PUBLIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: stm32f10x_it.c
  group APP
    ../User/APP/: app.c app_rtc.c app_init.c app_core.c app_can_tx.c app_can_filter.c app_esp8266.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h os_app_hooks.c
  group BSP
    ../User/BSP/: bsp.c bsp.h
    ../User/BSP/USART/: bsp_usart.c
    ../User/BSP/DELAY/: bsp_delay.c
    ../User/BSP/LED/: bsp_led.c
    ../User/BSP/LCD/: bsp_lcd.c
    ../User/BSP/FLASH/: bsp_flash.c
    ../User/BSP/SPI/: bsp_spi.c
    ../User/BSP/TOUCH/: bsp_touch.c
    ../User/BSP/EEPROM/: bsp_eeprom.c
    ../User/BSP/I2C/: bsp_i2c.c
    ../User/BSP/RTC/: bsp_rtc.c
    ../User/BSP/CAN/: bsp_can.c
    ../User/BSP/RC522/: bsp_rc522_function.c bsp_rc522_config.c
    ../User/BSP/BUZZER/: bsp_buzzer.c
    ../User/BSP/CRC/: bsp_crc.c
  group PUBLIC
    ../User/PUBLIC/: pub_chinese.c
  group uC/CPU
    ../User/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../User/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../User/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../User/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../User/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../User/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
